# Keil uVision project haltest.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32L432KCUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: haltest
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L432KCUx/STCubeGenerated/Src/: main.c stm32l4xx_it.c
    ./RTE/Device/STM32L432KCUx/STCubeGenerated/Inc/: stm32l4xx_it.h
software components: CMSIS:CORE 5.2.0, Device:STM32Cube HAL:ADC 1.9.0, Device:STM32Cube HAL:Common 1.9.0, Device:STM32Cube HAL:Cortex 1.9.0, Device:STM32Cube HAL:DMA 1.9.0, Device:STM32Cube HAL:GPIO 1.9.0, Device:STM32Cube HAL:I2C 1.9.0, Device:STM32Cube HAL:PWR 1.9.0, Device:STM32Cube HAL:RCC 1.9.0, Device:STM32Cube HAL:UART 1.9.0, Device:Startup 1.3.1
